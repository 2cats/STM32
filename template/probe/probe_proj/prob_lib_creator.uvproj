# Keil uVision project prob_lib_creator.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: prob_lib_creator (library)
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\inc\SMCIC\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group probe
    ../src/: bsp.c bsp_i2c.c bsp_int.c bsp_os.c bsp_periph.c bsp_ser.c cpu_c.c cpu_core.c lib_ascii.c lib_math.c lib_mem.c lib_str.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c probe_com.c probe_com_os.c probe_rs232.c probe_rs232_os.c probe_rs232c.c cpu_a.asm os_cpu_a.asm
