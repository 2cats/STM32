# Keil uVision project template.uvproj, settings and files
target Jlink (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\LIB\inc;..\CORE;..\FATFS\src;..\FATFS\SPI;..\FATFS\SD;..\mpu6050\I2C_analog;..\mpu6050\mpu600;..\UTILS\delay;..\UTILS\Filter;..\UTILS\usart;..\UTILS\millis;..\UTILS\PID;..\UTILS\sys;..\UTILS\ADCManager;..\UTILS\EXTIManager;..\UTILS\InputCatcher;..\UTILS\USARTBufReceiever;..\UTILS\DS18B20;..\UTILS\PWMManager;..\UTILS\USART2BufReceiever;..\UTILS\usart2;..\UCGUI\LIB;..\probe;..\probe\inc;..\UCGUI\inc;..\UTILS\OLED;..\UTILS\KeyFSM;..\UltraProbe;..\UTILS\PID_AutoTune;..\UTILS\THB7128;..\UTILS\RTC;..\UTILS\Protocol;..\UTILS\NRF24L01;..\UTILS\spi;..\UTILS\LCD;..\UTILS\doEvery;..\UTILS\DACManager;..\UTILS\ServoManager;..\UTILS\SuperTask;..\UTILS\USMART;..\UTILS\HX711;..\UTILS\24CXX;..\UTILS\IRremote;..\UTILS\KeyScan;..\UTILS\math;..\UTILS\NewKeyScan;..\newLib;..\UCGUI\GUI\HARDWARE\LCD;..\UCGUI\GUI\GUI\Config;..\UCGUI\GUI\GUI\Core;..\UCGUI\GUI\GUI\LCDDriver;..\UCGUI\GUI\GUI\Widget;..\UCGUI\GUI\GUI\WM;..\libcstl;..\newLib\eGUI;..\UCGUI\GUI\HARDWARE\TOUCH;..\GUI\STemWin5.22;..\GUI\STemWin5.22\INC;..\GUI\LCD;..\GUI\TOUCH;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: system_stm32f10x.c stm32f10x_it.c main.cpp GUI_main.cpp zshz.c
  group UTILS
    ../UTILS/ADCManager/: ADCManager.c
    ../UTILS/delay/: delay.c
    ../UTILS/DS18B20/: ds18b20.c
    ../UTILS/EXTIManager/: EXTIManager.c
    ../UTILS/Filter/: filter.c
    ../UTILS/InputCatcher/: InputCatcher.c
    ../UTILS/KeyFSM/: KeyFSM.c
    ../UTILS/millis/: millis.c
    ../UTILS/OLED/: JLX12864G.c
    ../UTILS/PID/: newPID.c
    ../UTILS/PWMManager/: PWMManager.c
    ../UTILS/sys/: sys.c
    ../UTILS/THB7128/: THB7128.c
    ../UTILS/RTC/: rtc.c
    ../UTILS/DACManager/: DACManager.c
    ../UTILS/ServoManager/: ServoManager.c
    ../UTILS/HX711/: HX711.c
    ../UTILS/24CXX/: 24cxx.c
    ../UTILS/IRremote/: IRremote.c
    ../UTILS/math/: mymath.c
    ../UTILS/NRF24L01/: 24l01.c
    ../UTILS/spi/: spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group LIBS
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mpu6050
    ../mpu6050/mpu600/: MPU6050.c
    ../mpu6050/I2C_analog/: iic_analog.c
  group newLib
    ../newLib/MKeyScan/: MKeyScan.c
    ../newLib/usart/: usart.cpp
    ../newLib/config/: Configure.cpp
    ../newLib/util/: util.cpp
    ../newLib/timer/: Timer.cpp TimerChannel.cpp
    ../newLib/Flash/: Flash.cpp
    ../newLib/buffer/: Buffer.cpp
    ../newLib/postman/: Postman.cpp
    ../newLib/NRF/: NRF.cpp
  group GUI
    ../GUI/LCD/: ili93xx.c
    ../GUI/TOUCH/: touch.c
    ../GUI/STemWin5.22/: GUI_X.c GUIConf.c GUIConf.h LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c STemWin522_CM3_Keil.lib gui_touch.c
    ../GUI/: mygui.cpp
  group eGUI
    ../newLib/eGUI/: GObject.cpp Menu.cpp MenuWidget.cpp Message.cpp Rectangle.cpp TextView.cpp CheckBoxMenu.cpp NumInputMenu.cpp InteractiveMenu.cpp StatusBar.cpp InputDevice.cpp
